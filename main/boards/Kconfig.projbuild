## main/boards/Kconfig.projbuild
```kconfig
menu "Borad Configuration"

  config Board_Version
      int "Board Version"
      default 1
      help
          Board Version

endmenu
```
